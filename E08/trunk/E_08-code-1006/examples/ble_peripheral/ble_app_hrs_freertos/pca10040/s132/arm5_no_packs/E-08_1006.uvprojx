# Keil uVision project E-08_1006.uvprojx, settings and files
target nrf52832_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: E_08_1006 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 xCONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS USE_APP_CONFIG CONFIG_NFCT_PINS_AS_GPIOS xDEBUG
  c include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mailbox;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config;..\..\..\..\..\..\components\ble\ble_services\ble_user_services;..\..\..\source;..\..\..\source\protocol;..\..\..\source\bsp;..\..\..\source\app_task;..\..\..\source\app_handler;..\..\..\source\sport;..\..\..\source\bsp\simulating_IIC;..\..\..\source\heart;..\..\..\source\heart\nrf_52;..\..\..\source\blood_press;..\..\..\source\blood_press\nrf_52;..\..\..\source\flash;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\source\watch_dog;..\..\..\source\motor_event;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\libraries\simple_timer;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\source\battery;..\..\..\source\guilib;..\..\..\source\guilib\LCD_64x128;..\..\..\source\timer;..\..\..\source\app_ancs;..\..\..\source\app_ancs\phone_event;..\..\..\source\uicr_config;..\..\..\source\daily_info;..\..\..\source\afe4404;..\..\..\source\sleep;..\..\..\source\dfu;..\..\..\source\fontlib;..\..\..\source\guilib\ICon;..\..\..\..\..\..\components\libraries\log;..\..\..\source\outsit;..\..\..\source\camera;..\..\..\source\bsp\simulating_SPI;..\..\..\source\afe4900;..\..\..\source\Thread;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\source\Thread\Algorithm;..\..\..\source\Thread\Communication;..\..\..\source\Thread\GUI;..\..\..\source\Thread\BleStack;..\..\..\source\Lib;..\..\..\source\Lib\gesture;..\..\..\source\Lib\pedometer;..\..\..\source\Lib\sleep;..\..\..\source\Driver\Gensor;..\..\..\source\camera;..\..\..\source\app_flash;..\..\..\source\Driver\ADC;..\..\..\source\common;..\..\..\source\common\type;..\..\..\source\common\config;..\..\..\source\common\log;..\..\..\source\common\util;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\source\movement_patterns;..\..\..\source\acc;..\..\..\source\bsp\ext_flash;..\..\..\source\ble_disconnect;..\..\..\source\women_function;..\..\..\source\Lib\afe4404_cal;..\..\..\source\common\crc;..\..\..\source\Lib\ecg;..\..\..\source\Lib\ppg;..\..\..\source\Lib\wear;..\..\..\source\si1182;..\..\..\source\Lib\oxygen;..\..\..\source\Lib\Osahs
  asm define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DFREERTOS
  asm include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mailbox;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x51000
  memory RVCT9: RAM 0x20002800 size 0xd800
  group Application
    ../../../: main.c
    ../../../source/watch_dog/: watch_dog.c
    ../../../source/motor_event/: motor_event.c
    ../../../source/sleep/: sleep.c
    ../../../source/protocol/: bracelet_protocol.c
    ../../../source/movement_patterns/: movement_patterns.c
    ../../../source/ble_disconnect/: ble_disconnect_remind.c
    ../../../source/common/: test_interface.h test_interface.c test_mode.h
    ../../../source/common/config/: configuration.h
  group Thread
    ../../../source/common/: test_mode.c
    ../../../source/Thread/Algorithm/: algorithm_thread.c
    ../../../source/Thread/Communication/: communication_thread.c
    ../../../source/Thread/BleStack/: ble_thread.c
    ../../../source/Thread/GUI/: gui_thread.c
    ../../../source/Thread/: data_manage.h data_manage.c event_manage.h event_manage.c test_state_machine.c test_state_machine.h
  group Common
    ../../../source/common/util/: util.h util.c
    ../../../source/common/crc/: app_crc16.h app_crc16.c
    ../../../source/common/type/: common_data_type.h cpu_task_data_type.h event_priority.h flash_data_type.h calc_data_type.h
    ../../../source/common/log/: log.h
  group VpDriver
    ../../../source/Driver/ADC/: battery_adc.c
    ../../../source/acc/: posture_get.c
    ../../../source/Driver/Gensor/: GSensor.c
  group Si1182
    ../../../source/si1182/: si1182_config.h si1182_driver.c si1182_driver.h si1182_functions.c si1182_functions.h si1182_handle.c si1182_handle.h si1182_interface.c si1182_interface.h si1182_calibration.c si1182_calibration.h
  group Lib
    ../../../source/Lib/: vph_solo_v2_52.lib
    ../../../source/Lib/gesture/: gesture_12bit_nrf52_03010800_20171019.lib
    ../../../source/Lib/sleep/: Acculate_SleepAlgorithm.h Acculate_CurrentState.h AcculateSleepAlgorithm_nrf52832_ReduceRam_02000410_20190701.lib
    ../../../source/Lib/ecg/: ecg_detect.h 1182_ECG_nrf52_02000400_20190515.lib
    ../../../source/Lib/Osahs/: Spo2_OSAHS.h 1182_Spo2_Osahs_nrf52832_02050005_20190619.lib
    ../../../source/Lib/oxygen/: Blood_OxygenDetection.h spo2_1182_calib.h si1182_SPO2_8mmLEDPD_E_10000150_20190710.lib
    ../../../source/Lib/wear/: no_weardetect_nrf52832_01010701_20190429.lib
    ../../../source/Lib/ppg/: pwave_infoalgorithm.h Si1182_PPG_nrf52832_01010207_20190615.lib
    ../../../source/Lib/pedometer/: pedometer.h pedometer_nrf52832_02031100_20190716.lib
  group Timer
    ../../../source/timer/: SystemTime.c time_manage.c app_rtc.c alarm_event.c
  group Flash
    ../../../source/app_flash/: api_flash.c app_config_data.c Dev_SN_Check.c flash_common.c flash_record_data.c api_ext_flash.c api_ext_flash.h
  group Guilib
    ../../../source/guilib/: CPU_EventTask.c CPU_GeneralTask.c gui_data_inteface.c gui_flash_param.c gui_flash_param.h gui_font_lattice.c gui_page_display.c gui_traverse.c lcd_driver_tft.c tft_icon_const.c gui_flash_addr.h
  group Ancs
    ../../../source/app_ancs/: app_ancs.c ancs_notify_event.c app_hid.c
  group Board Support
    ../../../source/bsp/simulating_IIC/: twi_sw_master.h twi_sw_master.c I2C.h I2C.c
    ../../../source/bsp/: bsp_iic.c bsp_spi.c bsp_btn_ble.c backlight_driving.c
    ../../../source/bsp/ext_flash/: ext_flash.c
    ../../../source/common/config/: board.h
  group Fontlib
    ../../../source/fontlib/: HFMA2Ylib_52832.lib fontlib_spi.c
  group Dfu
    ../../../source/dfu/: user_bootloader.c
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../../external/freertos/portable/ARM/nrf52/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../components/ble/ble_services/ble_hids/: ble_hids.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_user_services/: ble_clk.c ble_nus.c ble_wechat_service.c ble_wechat_service.h ble_wechat_util.c ble_wechat_util.h
    ../../../../../../components/ble/ble_services/ble_ancs_c/: ble_ancs_c.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/hal/: nrf_saadc.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../../../components/libraries/pwm/: app_pwm.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.7.1
