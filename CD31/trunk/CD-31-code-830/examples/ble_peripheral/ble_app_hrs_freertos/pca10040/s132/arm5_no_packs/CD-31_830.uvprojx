# Keil uVision project CD-31_830.uvprojx, settings and files
target nrf52832_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: CD_31_830 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=6144 __HEAP_SIZE=2048 S132 NRF_SD_BLE_API_VERSION=3 BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 xCONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS USE_APP_CONFIG CONFIG_NFCT_PINS_AS_GPIOS xDEBUG
  c include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mailbox;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config;..\..\..\..\..\..\components\ble\ble_services\ble_user_services;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\libraries\simple_timer;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\source;..\..\..\source\protocol;..\..\..\source\bsp;..\..\..\source\bsp\simulating_IIC;..\..\..\source\bsp\ext_flash;..\..\..\source\app_task;..\..\..\source\app_handler;..\..\..\source\acc;..\..\..\source\sport;..\..\..\source\heart;..\..\..\source\blood_press;..\..\..\source\app_flash;..\..\..\source\motor_event;..\..\..\source\watch_dog;..\..\..\source\battery;..\..\..\source\guilib;..\..\..\source\timer;..\..\..\source\adc;..\..\..\source\app_ancs;..\..\..\source\app_ancs\phone_event;..\..\..\source\uicr_config;..\..\..\source\daily_info;..\..\..\source\sleep;..\..\..\source\dfu;..\..\..\source\fontlib;..\..\..\source\wear_dect;..\..\..\source\outsit;..\..\..\source\camera;..\..\..\source\fatigue;..\..\..\source\bsp\simulating_SPI;..\..\..\source\common;..\..\..\source\alarm_event;..\..\..\source\app_hid;..\..\..\source\lib\bp;..\..\..\source\lib\gesture;..\..\..\source\lib\heart;..\..\..\source\lib\pedometer;..\..\..\source\lib\sleep;..\..\..\source\lib\tired;..\..\..\source\lib\vph_solo;..\..\..\source\lib\wear_dect;..\..\..\source\movement_patterns;..\..\..\source\women_function;..\..\..\source\TouchChip;..\..\..\source\lib\tp
  asm define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=4096 __HEAP_SIZE=2048 S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DFREERTOS
  asm include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mailbox;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x4b000
  memory RVCT9: RAM 0x20004000 size 0xc000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
    ../../../source/protocol/: bracelet_protocol.c bracelet_protocol.h
    ../../../source/app_task/: app_task.h app_task.c
    ../../../source/: app_config.h app_type.h app_config_data.c app_config_data.h configuration.h
    ../../../source/app_handler/: app_handler.c app_handler.h
    ../../../source/watch_dog/: watch_dog.c
    ../../../source/motor_event/: motor_event.c
    ../../../source/uicr_config/: uicr_config.h
    ../../../source/common/: app_crc16.c app_crc16.h app_adc_send.c app_adc_send.h util.c util.h
  group Heart
    ../../../source/heart/: heart.c heart.h
  group Acc
    ../../../source/acc/: hal_acc_calculate.c hal_acc_calculate.h posture_get.c posture_get.h hal_acc.h hal_acc.c
    ../../../source/movement_patterns/: movement_patterns.c movement_patterns.h
  group Blood_Pressure
    ../../../source/blood_press/: blood_pressure.c blood_pressure.h
  group Timer
    ../../../source/timer/: app_rtc.c app_rtc.h system_clock.c system_clock.h timer_manage.c timer_manage.h
  group Flash
    ../../../source/app_flash/: app_flash.c app_flash.h app_storage.c app_storage.h product_info.c product_info.h
  group Daily_Info
    ../../../source/daily_info/: daily_info.c daily_info.h daily_test.c daily_test.h
  group Sleep
    ../../../source/sleep/: sleep.c sleep.h
  group Outsit
    ../../../source/outsit/: outsit.c outsit.h
  group AlarmClock
    ../../../source/alarm_event/: alarm_event.c alarm_event.h ble_disconnect_remind.c ble_disconnect_remind.h
  group Ancs
    ../../../source/app_ancs/: app_ancs.c app_ancs.h ancs_notify_event.c ancs_notify_event.h
    ../../../source/app_ancs/phone_event/: Phone_notify_event.c Phone_notify_event.h phone_notify_roll_event.c phone_notify_roll_event.h
  group Hid
    ../../../source/app_hid/: app_hid.c app_hid.h
  group Camera
    ../../../source/camera/: phone_camera_event.c phone_camera_event.h
  group Physiological
    ../../../source/women_function/: physiological_remind_words.h physiological_remind_words.c physiological_period.h physiological_period.c physiological_remind_words_en.c physiological_remind_words_en.h physiological_remind_words_french.c physiological_remind_words_french.h physiological_remind_words_german.c physiological_remind_words_german.h physiological_remind_words_italiarn.c physiological_remind_words_italiarn.h physiological_remind_words_japan.c physiological_remind_words_japan.h physiological_remind_words_korean.c physiological_remind_words_korean.h physiological_remind_words_portuguese.c physiological_remind_words_portuguese.h physiological_remind_words_russian.c physiological_remind_words_russian.h physiological_remind_words_spanish.c physiological_remind_words_spanish.h physiological_remind_words_traditional.c physiological_remind_words_traditional.h physiological_remind_words_vietnanese.h physiological_remind_words_vietnanese.c
  group Wear_Dect
    ../../../source/wear_dect/: pwm.c pwm.h vph_wear_dect.c vph_wear_dect.h
  group Fontlib
    ../../../source/fontlib/: HFMA2Ylib.h HFMA2Ylib_52832.lib fontlib_spi.c fontlib_spi.h
  group Guilib
    ../../../source/guilib/: lcd_driver_tft.c lcd_driver_tft.h gui_data_inteface.c gui_data_inteface.h cpu_common.h cpu_event_task.c cpu_event_task.h cpu_general_task.c cpu_general_task.h gui_font_lattice.c gui_font_lattice.h gui_page_display.c gui_page_display.h gui_thread.c gui_thread.h tft_icon_const.c tft_icon_const.h gui_update.c gui_update.h gui_flash_addr.h gui_flash_param.c gui_flash_param.h gui_traverse.c gui_traverse.h
  group TouchChip
    ../../../source/TouchChip/: tp_manage.c tp_manage.h zinitix.c zinitix_touch.h zinitix_touch_zxt_firmware.h
  group Lib
    ../../../source/lib/vph_solo/: vph_solo_v2_52_01.lib
    ../../../source/lib/gesture/: gesture_test.h gesture_12bit_nrf52_03010800_20171019.lib
    ../../../source/lib/heart/: pulse_rate_sport_version.h sport_pulse_nrf52_05020200_20170929.lib
    ../../../source/lib/sleep/: Vph_CurrentState.h Vph_SleepAlgorithm.h SleepAlgorithm_nrf52_01080000_20170906.lib
    ../../../source/lib/wear_dect/: nowear_detection.h nowear_detection_nrf52_01011200_20171229.lib photoele_wear_detect.h photoele_wear_detect_nrf52_0x01010400_20170914.lib
    ../../../source/lib/tp/: tp_cal_data.c tp_cal_data.h tp_gesture.c tp_gesture.h
    ../../../source/lib/pedometer/: pedometer.h pedometer_nrf52_02030800_20180903.lib
    ../../../source/lib/bp/: bp_sports_12bit_nrf52832_01010900_20190326.lib vph_bp.h
  group ADC
    ../../../source/adc/: adc.h adc_52832.c
  group Board Support
    ../../../source/bsp/simulating_IIC/: twi_sw_master.c I2C.c
    ../../../source/bsp/: bsp_iic.h bsp_iic.c bsp_spi.c bsp_led.c bsp_led.h board.h bsp_button.c bsp_button.h backlight_driving.h backlight_driving.c
    ../../../source/battery/: battery.h battery_52832.c
    ../../../source/bsp/simulating_SPI/: spi_master.c spi_master.h
    ../../../source/bsp/ext_flash/: ext_flash.c ext_flash.h
  group Dfu
    ../../../source/dfu/: user_bootloader.c user_bootloader.h
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../../external/freertos/portable/ARM/nrf52/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_user_services/: ble_clk.c ble_nus.c ble_wechat_service.c ble_wechat_service.h ble_wechat_util.c ble_wechat_util.h
    ../../../../../../components/ble/ble_services/ble_ancs_c/: ble_ancs_c.c
    ../../../../../../components/ble/ble_services/ble_hids/: ble_hids.c ble_hids.h
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/hal/: nrf_saadc.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../../../components/libraries/pwm/: app_pwm.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.7.1
