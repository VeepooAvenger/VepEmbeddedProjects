# Keil uVision project S-26-332.uvprojx, settings and files
target nrf52832_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: S_26_332 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 xCONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS USE_APP_CONFIG CONFIG_NFCT_PINS_AS_GPIOS xDEBUG
  c include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mailbox;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config;..\..\..\..\..\..\components\ble\ble_services\ble_user_services;..\..\..\source;..\..\..\source\protocol;..\..\..\source\bsp;..\..\..\source\app_task;..\..\..\source\app_handler;..\..\..\source\sport;..\..\..\source\bsp\simulating_IIC;..\..\..\source\heart;..\..\..\source\heart\nrf_52;..\..\..\source\blood_press;..\..\..\source\blood_press\nrf_52;..\..\..\source\flash;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\source\watch_dog;..\..\..\source\motor_event;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\libraries\simple_timer;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\source\battery;..\..\..\source\guilib;..\..\..\source\guilib\LCD_64x128;..\..\..\source\timer;..\..\..\source\app_ancs;..\..\..\source\app_ancs\phone_event;..\..\..\source\uicr_config;..\..\..\source\daily_info;..\..\..\source\afe4404;..\..\..\source\sleep;..\..\..\source\dfu;..\..\..\source\fontlib;..\..\..\source\guilib\ICon;..\..\..\..\..\..\components\libraries\log;..\..\..\source\outsit;..\..\..\source\camera;..\..\..\source\bsp\simulating_SPI;..\..\..\source\afe4404;..\..\..\source\Thread;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\source\Thread\Algorithm;..\..\..\source\Thread\Communication;..\..\..\source\Thread\GUI;..\..\..\source\Thread\BleStack;..\..\..\source\Lib;..\..\..\source\Lib\gesture;..\..\..\source\Lib\oxygen;..\..\..\source\Lib\pedometer;..\..\..\source\Lib\tired;..\..\..\source\Lib\sleep;..\..\..\source\Lib\hrv;..\..\..\source\Lib\wear;..\..\..\source\Driver\Gensor;..\..\..\source\camera;..\..\..\source\app_flash;..\..\..\source\Driver\ADC;..\..\..\source\Lib\br;..\..\..\source\common\type;..\..\..\source\Lib\heart;..\..\..\source\Lib\Osahs;..\..\..\source\common\config;..\..\..\source\common\log;..\..\..\source\common\util;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\source\movement_patterns;..\..\..\source\acc;..\..\..\source\bsp\ext_flash;..\..\..\source\ble_disconnect;..\..\..\source\women_function;..\..\..\source\Lib\afe4404_cal;..\..\..\source\afe4900;..\..\..\source\Lib\bp;..\..\..\source\common\test
  asm define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DFREERTOS
  asm include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mailbox;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x39000
  memory RVCT9: RAM 0x20002700 size 0xd900
  group Application
    ../../../: main.c
    ../../../source/watch_dog/: watch_dog.c
    ../../../source/motor_event/: motor_event.c
    ../../../source/sleep/: sleep.c
    ../../../source/common/util/: util.c
    ../../../source/protocol/: bracelet_protocol.c
    ../../../source/movement_patterns/: movement_patterns.c
    ../../../source/ble_disconnect/: ble_disconnect_remind.c
    ../../../source/common/config/: configuration.h
    ../../../source/common/test/: test_mode.c test_mode.h
  group Thread
    ../../../source/Thread/Algorithm/: algorithm_thread.c
    ../../../source/Thread/Communication/: communication_thread.c
    ../../../source/Thread/: data_manage.c event_manage.c
    ../../../source/Thread/GUI/: gui_thread.c
    ../../../source/Thread/BleStack/: ble_thread.h ble_thread.c
  group AFE4900
    ../../../source/afe4900/: afe4900_calibration.c afe4900_calibration.h afe4900_driver.c afe4900_driver.h afe4900_entry.c afe4900_entry.h afe4900_init.c afe4900_init.h calc_data_type.h
  group VpDriver
    ../../../source/Driver/Gensor/: GSensor.c
    ../../../source/Driver/ADC/: battery_adc.c
    ../../../source/acc/: posture_get.c
  group Lib
    ../../../source/Lib/: vph_solo_v2_52.lib
    ../../../source/Lib/gesture/: gesture_12bit_nrf52_03010800_20171019.lib
    ../../../source/Lib/sleep/: SleepAlgorithm_nrf52_01090000_20171121.lib
    ../../../source/Lib/hrv/: hrv_detection_bit24_01020800_20180110.lib
    ../../../source/Lib/wear/: no_weardetect_bit24_01010700_20180517.lib afe4410_signal_wear_detection_nrf52832_01010202_20190605.lib
    ../../../source/Lib/br/: respiratory_rate_bit24_01010900_20180823.lib
    ../../../source/Lib/oxygen/: Blood_OxygenDetection.h Blood_OxygenCalib.h 4410_S-26_SPO2_watch_nrf52_03020710_20190727.lib
    ../../../source/Lib/afe4404_cal/: Afe4410_HrCalib.h 4410_calib_nrf52_S_hr_01010900_20190518.lib
    ../../../source/Lib/tired/: tired_24bit_50Hz_nrf52832_01010100_20190523.lib
    ../../../source/Lib/bp/: vph_bp_24bit_nrf52832_02000103_20190402.lib vph_bp_24bit.h
    ../../../source/Lib/heart/: pulse_24bit_50hz_nrf52_06030100_20180628.lib
    ../../../source/Lib/Osahs/: 4410_Spo2_Osahs_nrf52832_02050020_20190727.lib
    ../../../source/Lib/pedometer/: pedometer_nrf52832_02031100_20190716.lib
  group Timer
    ../../../source/timer/: SystemTime.c time_manage.c app_rtc.c
  group Flash
    ../../../source/app_flash/: api_flash.c app_config_data.c Dev_SN_Check.c flash_common.c flash_record_data.c
  group Guilib
    ../../../source/guilib/: CPU_EventTask.c CPU_GeneralTask.c gui_data_inteface.c gui_flash_param.c gui_font_lattice.c gui_page_display.c gui_traverse.c lcd_driver_tft.c tft_icon_const.c gui_flash_addr.h
  group Ancs
    ../../../source/app_ancs/: app_ancs.c ancs_notify_event.c app_hid.c
  group Board Support
    ../../../source/bsp/: bsp_iic.c bsp_spi.c bsp_btn_ble.c bsp_led.c
    ../../../source/bsp/ext_flash/: ext_flash.c
    ../../../source/common/config/: board.h
  group Fontlib
    ../../../source/fontlib/: HFMA2Ylib_52832.lib fontlib_spi.c
  group Dfu
    ../../../source/dfu/: user_bootloader.c
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../../external/freertos/portable/ARM/nrf52/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../components/ble/ble_services/ble_hids/: ble_hids.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_user_services/: ble_clk.c ble_nus.c ble_wechat_service.c ble_wechat_service.h ble_wechat_util.c ble_wechat_util.h
    ../../../../../../components/ble/ble_services/ble_ancs_c/: ble_ancs_c.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/hal/: nrf_saadc.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../../../components/libraries/pwm/: app_pwm.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\config\ble_app_hrs_freertos_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.7.1
